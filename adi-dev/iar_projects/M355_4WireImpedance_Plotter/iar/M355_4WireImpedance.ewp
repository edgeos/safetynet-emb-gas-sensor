# IAR project M355_4WireImpedance.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\common; ..\..\..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: M355_4WireImpedance.srec
  ILINK.IlinkOutputFile: M355_4wireImpedance_Plotter.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: FreqArray.c M355_4WireImpedance_Plotter.c Uart_Plotter_Control.c
  group common
    ../../../common/: AfeAdcLib.c AfeDacLib.c AfeTiaLib.c AfeWdtLib.c ClkLib.c DioLib.c PwrLib.c UrtLib.c
  group startup
    ../../../common/IAR/: startup.c system.c
